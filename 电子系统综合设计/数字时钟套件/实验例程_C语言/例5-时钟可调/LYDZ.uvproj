# Keil uVision project LYDZ.uvproj, settings and files
target LYDZ (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: LYDZ +hex
  c flags: Optimize=8 SizeSpeed=1
  group MAIN
    ./: STARTUP.A51 main.c
